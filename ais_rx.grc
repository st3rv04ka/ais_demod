options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: ais_rx
    output_language: python
    title: AIS
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: '88'
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: '87'
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: 87_raw
    type: byte
  states: {}
- name: blocks_file_sink_0_0_1
  id: blocks_file_sink
  parameters:
    file: 88_raw
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/bbb/Projects/ais/ais_central2.iq
    repeat: 'True'
    type: complex
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_NRZI
    modulus: '1'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_NRZI
    modulus: '1'
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.5'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '4'
  states: {}
- name: digital_gmsk_demod_0_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.5'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '4'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 25e3
    decim: '20'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 15000, 20000,  window.WIN_HAMMING, 6.76)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-25e3'
    decim: '20'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 15000, 20000,  window.WIN_HAMMING, 6.76)
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    interp: '48'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    interp: '48'
    type: ccc
  states: {}

connections:
- [blocks_file_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_file_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_file_sink_0, '0']
- [digital_diff_decoder_bb_0_0, '0', blocks_file_sink_0_0, '0']
- [digital_gmsk_demod_0, '0', blocks_file_sink_0_0_1, '0']
- [digital_gmsk_demod_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_gmsk_demod_0_0, '0', blocks_file_sink_0_0_0, '0']
- [digital_gmsk_demod_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0, '0', digital_gmsk_demod_0, '0']
- [rational_resampler_xxx_0_0, '0', digital_gmsk_demod_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
